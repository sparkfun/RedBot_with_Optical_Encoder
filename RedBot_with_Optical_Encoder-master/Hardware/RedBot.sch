# EAGLE design RedBot (EAGLE 6.4)

## Parts
C2  0.1uF  0.1UF-25V(+80/-20%)(0603)  [0603-CAP]
C3  0.1uF  0.1UF-25V(+80/-20%)(0603)  [0603-CAP]
C4  0.1uF  0.1UF-25V(+80/-20%)(0603)  [0603-CAP]
C5  0.1uF  0.1UF-25V(+80/-20%)(0603)  [0603-CAP]
C6  0.1uF  0.1UF-25V(+80/-20%)(0603)  [0603-CAP]
C7  0.1uF  0.1UF-25V(+80/-20%)(0603)  [0603-CAP]
C8  10uF  10UF-16V-10%(TANT)  [EIA3216]
C9  10uF  10UF-16V-10%(TANT)  [EIA3216]
D1  B340A  [SMA-DIODE]
D2  B340A  [SMA-DIODE]
D3  GREEN  LED-GREEN0603  [LED-0603]
D4  GREEN  LED-GREEN0603  [LED-0603]
D5  GREEN  LED-GREEN0603  [LED-0603]
D6  GREEN  LED-GREEN0603  [LED-0603]
FID1  FIDUCIALUFIDUCIAL  [MICRO-FIDUCIAL]
FID2  FIDUCIALUFIDUCIAL  [MICRO-FIDUCIAL]
FRAME1  FRAME-LETTER  [CREATIVE_COMMONS]
JP1  1x3 RA Female .1"  M03SMD_RA_FEMALE  [1X03_SMD_RA_FEMALE]
JP2  1x3 RA Female .1"  M03SMD_RA_FEMALE  [1X03_SMD_RA_FEMALE]
JP3  5.5x2.1mm Barrel  POWER_JACKSMD  [POWER_JACK_SMD]
JP4  USB-B  USB-MINIB-5PIN  [USB-MINIB]
JP5  AVR_SPI_PRG_6PTH  [2X3]
JP6  M05X2NO_SILK  [2X5_NOSILK]
JP7  M05X2NO_SILK  [2X5_NOSILK]
JP8  M03X2SMT  [2X3_SMT_POSTS]
JP9  M03X2SMT  [2X3_SMT_POSTS]
JP10  M03X2SMT  [2X3_SMT_POSTS]
JP11  M03X2SMT  [2X3_SMT_POSTS]
JP12  M03X2SMT  [2X3_SMT_POSTS]
JP13  M03X2SMT  [2X3_SMT_POSTS]
JP14  M02PTH  [1X02]
JP15  M02PTH  [1X02]
JP16  M02PTH  [1X02]
MOD1  XBEE-1B3  [XBEE-SMD]
Q1  IRF7509  [MSOP8]
R1  10k  10KOHM1/10W1%(0603)0603  [0603-RES]
R2  1k  1K-1%  [0603-RES]
R3  1k  1K-1%  [0603-RES]
R4  1k  1K-1%  [0603-RES]
R5  1k  1K-1%  [0603-RES]
R6  1k  1K-1%  [0603-RES]
R7  1k  1K-1%  [0603-RES]
R8  1k  1K-1%  [0603-RES]
R9  10k  10KOHM1/10W1%(0603)0603  [0603-RES]
R10  10k  10KOHM1/10W1%(0603)0603  [0603-RES]
R11  10k  10KOHM1/10W1%(0603)0603  [0603-RES]
R12  10k  10KOHM1/10W1%(0603)0603  [0603-RES]
R13  10k  10KOHM1/10W1%(0603)0603  [0603-RES]
S1  DPDT  SWITCH-DPDTAYZ0202  [AYZ0202]
S2  DPDT  SWITCH-DPDTAYZ0202  [AYZ0202]
S3  DPDT  SWITCH-DPDTAYZ0202  [AYZ0202]
S4  TAC_SWITCHSMD  [TACTILE_SWITCH_SMD]
SFE-LOGO1  LOGO-SFENEW  [SFE-NEW-WEBLOGO]
STANDOFF1  STAND-OFF  [STAND-OFF]
STANDOFF2  STAND-OFF  [STAND-OFF]
STANDOFF3  STAND-OFF  [STAND-OFF]
STANDOFF4  STAND-OFF  [STAND-OFF]
U1  ATMEGA328P  ATMEGA328_SMT  [TQFP32-08]
U2  TB6612FNG  TB6621FNG  [SSOP24]
U3  MIC5219 5V  V_REG_MIC52195V  [SOT23-5]
U4  MIC5219 3.3V  V_REG_MIC52193.3V  [SOT23-5]
U5  FT232RLSSOP  [SSOP28DB]
U6  7408SE  [SOT353]
U$17  OSHW-LOGOS  [OSHW-LOGO-S]
U$21  FOUR_LAYER_WARNING  [FOUR_LAYER_WARNING]
Y1  16MHz  RESONATOR16MHZ  [RESONATOR-SMD]

## Nets
3.3V: C6.1 C8.A(+) MOD1.1(VDD) U4.5(OUT)
5V: C2.1 C3.1 C4.1 C9.A(+) JP5.2 JP6.1 JP6.3 JP6.5 JP6.7 JP6.9 JP7.1 JP7.3 JP7.5 JP7.7 JP7.9 JP10.3 JP10.4 JP11.3 JP11.4 JP12.3 JP12.4 JP13.3 JP13.4 R1.1 R8.2 R12.2 R13.2 U1.4(VCC) U1.6(VCC) U1.18(AVCC) U2.20(VCC) U3.5(OUT) U4.1(IN) U4.3(EN) U6.5(VCC)
AREF: U1.20(AREF)
FT232_RXI: R3.1 U5.5(RXD)
FT232_TXO: R2.1 U5.1(TXD)
FTDI_DTR: R13.1 U5.2(DTR) U6.1(A)
GND: C2.2 C3.2 C4.2 C5.2 C6.2 C8.C(-) C9.C(-) D4.C D6.C JP3.GND(GNDBREAK) JP3.P$4(GND) JP4.GND JP5.6 JP6.2 JP6.4 JP6.6 JP6.8 JP6.10 JP7.2 JP7.4 JP7.6 JP7.8 JP7.10 JP8.5 JP8.6 JP9.5 JP9.6 JP10.5 JP10.6 JP11.5 JP11.6 JP12.5 JP12.6 JP13.5 JP13.6 JP16.1 MOD1.10(GND) Q1.1(NMOS:S) S1.3 S1.6 S2.3 S4.1 U1.3(GND) U1.5(GND) U1.21(AGND) U2.3(PGND1) U2.4(PGND1) U2.9(PGND2) U2.10(PGND2) U2.18(GND) U3.2(GND) U4.2(GND) U5.7(GND7) U5.18(GND18) U5.21(GND21) U5.25(AGND) U5.26(TEST) U6.3(GND) Y1.2
L01: JP1.1 JP1.3 JP15.2 U2.1(A01) U2.2(A01)
L02: JP1.2 JP15.1 U2.5(A02) U2.6(A02)
L_CTRL_1: U1.32(PD2(INT0)) U2.21(AIN1)
L_CTRL_2: U1.2(PD4(XCK/T0)) U2.22(AIN2)
MISO: JP5.1 U1.16(PB4(MISO))
MOTOR_ENABLE: S1.5 S2.2 U2.19(STBY)
N$1: R4.2 S3.2
N$2: Q1.4(PMOS:G) Q1.7(NMOS:D) Q1.8(NMOS:D) R11.1
N$3: D5.C R6.1
N$4: D3.C R5.1
N$5: C7.2 U6.4(Y)
N$6: JP4.MTN1(MTN2) JP4.MTN2(MTN3) JP4.MTN3(MTN1) JP4.MTN4
N$7: D4.A R7.1
N$8: D6.A R8.1
N$18: R9.1 S2.1
N$23: U1.8(PB7(XTAL2/TOSC2)) Y1.3
N$24: U1.7(PB6(XTAL1/TOSC1)) Y1.1
N$26: JP4.D- U5.16(USBDM)
N$27: JP4.D+ U5.15(USBDP)
PG_EN: R10.1 S1.1
PROGRAM_ENABLE: Q1.2(NMOS:G) S1.2 U3.3(EN)
PWML: U1.9(PD5(T1)) U2.23(PWMA)
PWMR: U1.10(PD6(AIN0)) U2.15(PWMB)
R01: JP2.1 JP2.3 JP14.2 U2.11(B01) U2.12(B01)
R02: JP2.2 JP14.1 U2.7(B02) U2.8(B02)
R_CTRL_1: U1.11(PD7(AIN1)) U2.17(BIN1)
R_CTRL_2: U1.12(PB0(ICP)) U2.16(BIN2)
RESET: C7.1 JP5.5 R1.2 S4.3 U1.29(PC6(/RESET))
RXI: R2.2 S3.4 U1.30(PD0(RXD))
RXLED: R5.2 U5.22(RXLED)
SCK: JP5.3 R7.2 U1.17(PB5(SCK))
SENSOR_0/SW_TXO: JP10.1 S3.3 U1.23(PC0(ADC0))
SENSOR_1/SW_RXI: JP10.2 S3.6 U1.24(PC1(ADC1))
SENSOR_2: JP11.1 U1.25(PC2(ADC2))
SENSOR_3: JP11.2 U1.26(PC3(ADC3))
SENSOR_4: JP12.1 U1.27(PC4(ADC4/SDA))
SENSOR_5: JP12.2 U1.28(PC5(ADC5/SCL))
SENSOR_6: JP13.1 U1.19(ADC6)
SENSOR_7: JP13.2 U1.22(ADC7)
SERVO_1: JP8.1 U1.1(PD3(INT1))
SERVO_2: JP8.2 U1.13(PB1(OC1A))
SERVO_3: JP9.1 U1.14(PB2(SS/OC1B))
SERVO_4/MOSI: JP5.4 JP9.2 U1.15(PB3(MOSI/OC2))
TXLED: R6.2 U5.23(TXLED)
TXO: R3.2 S3.1 U1.31(PD1(TXD))
V_BATT: D1.A JP3.VIN0(PWR) JP16.2 Q1.5(PMOS:D) Q1.6(PMOS:D) R11.2 U2.13(VM2) U2.14(VM3) U2.24(VM1)
V_GATED: JP8.3 JP8.4 JP9.3 JP9.4 Q1.3(PMOS:S)
V_IN: D1.C D2.C R9.2 R10.2 U3.1(IN)
V_USB: C5.1 D2.A D3.A D5.A JP4.VBUS U5.4(VCCIO) U5.20(VCC)
XBEE_DIO3: MOD1.17(DIO3) R12.1 U6.2(B)
XBEE_RXI: MOD1.3(DIN) R4.1
XBEE_TXO: MOD1.2(DOUT) S3.5
Unconnected: JP4.ID MOD1.4(DIO12) MOD1.5(RESET) MOD1.6(RSSI) MOD1.7(DIO11) MOD1.8(RES) MOD1.9(DTR) MOD1.11(DIO4) MOD1.12(CTS) MOD1.13(DIO9) MOD1.14(RES) MOD1.15(DIO5) MOD1.16(RTS) MOD1.18(DIO2) MOD1.19(DIO1) MOD1.20(DIO0) S1.4 S2.4 S2.5 S2.6 S4.2 S4.4 U3.4(BP) U4.4(BP) U5.3(RTS) U5.6(RI) U5.9(DSR) U5.10(DCD) U5.11(CTS) U5.12(SLEEP) U5.13(TXDEN) U5.14(PWREN) U5.17(3V3OUT) U5.19(RESET) U5.27(OSCI) U5.28(OSCO)

## Notes on the sheet
- M.Hord | 12

## Library data of the parts
C2-C7 = SparkFun-Capacitors:0.1UF-25V(+80/-20%)(0603): Ceramic; PROD_ID: CAP-00810
C8 C9 = SparkFun-Capacitors:10UF-16V-10%(TANT): CAP-00811; PROD_ID: CAP-00811
D1 D2 = SparkFun-DiscreteSemi:B340A: Schottky Diode; PROD_ID: DIO-09886
D3-D6 = SparkFun-LED:LED-GREEN: Various green LEDs; PROD_ID: DIO-00821
FID1 FID2 = SparkFun-Aesthetics:FIDUCIAL: Fiducial Alignment Points
FRAME1 = SparkFun-Aesthetics:FRAME-LETTER: Schematic Frame
JP1 JP2 = SparkFun-Connectors:M03: Header 3 Standard 3-pin 0.1" header. Use with straight break away headers (SKU : PRT-00116), right angle break away headers (PRT-00553), swiss pins (PRT-00743), machine pins (PRT-00117), and female headers (PRT-00115). Molex polarized connector foot print use with SKU : PRT-08232 with associated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; PROD_ID: CONN-10926
JP3 = SparkFun-Connectors:POWER_JACK: Power Jack This is the standard 5.5mm barrel jack for power. The PTH is the most common, proven, reliable, footprint. The Slot footprint only works if the mill layer is transmitted to the PCB fab house so be warned. Spark Fun Electronics SKU : PRT-00119 SMT: CONN-08106 Mating wall wart : TOL-00298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; PROD_ID: CONN-08106
JP4 = SparkFun-Connectors:USB-MINIB: Mini-USB "B" connector with 5th pin broken out. Created new symbol breaking out 5th "ID" pin in mini/micro USB connector spec. See: http://en.wikipedia.org/wiki/Mini_usb#Cables. Uses same footprint as 4-pin symbol. Also added pins to connect to mounting / shield pads if required (probably not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
JP5 = SparkFun-Connectors:AVR_SPI_PRG_6: AVR ISP 6 Pin This is the reduced ISP connector for AVR programming. Common on Arduino. This footprint will take up less PCB space and can be used with a 10-pin to 6-pin adapter such as SKU: BOB-08508
JP6 JP7 = SparkFun-Connectors:M05X2: Header 5x2 Standard 10-pin dual row 0.1" header. Commonly used with AVR-ISP. Use with Spark Fun Electronics SKU: PRT-00778
JP8-JP13 = SparkFun-Connectors:M03X2: 2x3 .1" header. Shrouded, with keying- CONN-10681 SMT- CONN-11415 Pogo pins- HW-11044; PROD_ID: CONN-11415
JP14-JP16 = SparkFun-Connectors:M02: Header 2
MOD1 = SparkFun-RF:XBEE-1: Xbee module footprints SMT header is CONN-09042.; PROD_ID: CONN-09042
Q1 = SparkFun-DiscreteSemi:IRF7509: 30V Dual PMOS/NMOS MSOP-8 NMOS RDS .11-ohm PMOS RDS .20-ohm TRANS-07913; PROD_ID: TRANS-07913
R1 R9-R13 = SparkFun-Resistors:10KOHM1/10W1%(0603): RES-00824; PROD_ID: RES-00824; VALUE: 10K
R2-R8 = SparkFun-Resistors:1K-1%: 1k-ohm SMT; PROD_ID: RES-07856
S1-S3 = SparkFun-Electromechanical:SWITCH-DPDT: DPDT Version of the COM-00597; PROD_ID: SWCH-08179
S4 = SparkFun-Electromechanical:TAC_SWITCH: Momentary Switch Button commonly used for reset or general input. Spark Fun Electronics SKU : COM-00097 SMT- SWCH-08247; PROD_ID: SWCH-08247
SFE-LOGO1 = SparkFun-Aesthetics:LOGO-SFE: Spark Fun Electronics PCB Logo
STANDOFF1-STANDOFF4 = SparkFun-Electromechanical:STAND-OFF: #4 Stand Off
U1 = SparkFun-DigitalIC:ATMEGA328_SMT: 32-Pin Atmega328 part Commonly used on Arduino compatible boards Available in QFP and QFN packages TQFP is IC-09069 QFN is non-stock; PROD_ID: IC-09069
U2 = SparkFun-PowerIC:TB6621FNG: Toshiba 1A dual motor driver IC-09363; PROD_ID: IC-09363
U3 = SparkFun-PowerIC:V_REG_MIC5219: V_REG MIC5219 Standard 500mA LDO voltage regulator in SOT-23 layout. Micrel part MIC5219. BP (by-pass) pin is used to lower output noise with 470pF cap, may be left open.; PROD_ID: VREG-10107
U4 = SparkFun-PowerIC:V_REG_MIC5219: V_REG MIC5219 Standard 500mA LDO voltage regulator in SOT-23 layout. Micrel part MIC5219. BP (by-pass) pin is used to lower output noise with 470pF cap, may be left open.; PROD_ID: VREG-09872
U5 = SparkFun-DigitalIC:FT232RL: USB UART FT232RL 4th Generation USB UART (USB <-> Serial) Controller. Spark Fun Electronics SKU : COM-00650 Production SKU IC-00870; PROD_ID: IC-00870
U6 = SparkFun-DigitalIC:74*08: Single 2-input AND gate 74LVC1G08SE-7 IC-10841; PROD_ID: IC-10841; VALUE: 74LVC1G08SE-7
U$17 = SparkFun-Aesthetics:OSHW-LOGO: Open Source Hardware Logo This logo indicates the piece of hardware it is found on incorporates a OSHW license and/or adheres to the definition of open source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
U$21 = SparkFun-Aesthetics:FOUR_LAYER_WARNING: Warning text which will appear on both the schematic
Y1 = SparkFun-FreqCtrl:RESONATOR: Resonator Small SMD resonator. Used, eg, on the Arduino Pro/ Pro Mini boards. 8MHz- XTAL-08895 16MHz- XTAL-08900; PROD_ID: XTAL-08900

## Board

Size 93.98 x 49.53 mm. Coordinates in mm from the lower left corner, seen from the top.
Outline: 0,46.99 0,2.54 arc90 2.54,0 91.44,0 arc90 93.98,2.54 93.98,46.99 arc90 91.44,49.53 2.54,49.53 arc90 0,46.99
Copper layers (1*2+15*16): Top 0.035mm / dielectric 1.5mm / 5V 0.035mm / dielectric 0.15mm / Gnd 0.035mm / dielectric 0.2mm / Bottom 0.035mm
Design rules "Sparkfun *": minimum track width 8mil, minimum drill 15mil, track to track 8mil, track to pad 8mil, pad to pad 8mil, via to via 8mil, smd to smd 8mil, copper to edge 8mil, drill to drill 8mil, minimum pad ring 12mil, minimum via ring 10mil, stop-mask expansion 4mil, vias tented up to drill 20mil, thermal gap 10mil

### Footprints (pad centres in the part's own frame; a part is rotated, then mirrored left to right if it is on the bottom)
0603-CAP = smd 1.1 x 1: 1 -0.85,0; 2 0.85,0
EIA3216 = smd 1.4 x 1.6: A 1.4,0; C -1.4,0
SMA-DIODE = smd 1.27 x 1.47: A -2.15,0; C 2.15,0
LED-0603 = smd 0.8 x 0.8: A 0,-0.75; C 0,0.75
MICRO-FIDUCIAL = smd 0.635 x 0.635: 1 0,0
1X03_SMD_RA_FEMALE = smd 1.25 x 3: 1 -2.54,7.225; 2 0,7.225; 3 2.54,7.225
POWER_JACK_SMD = smd 2.8 x 2.4: GND 0,-5.7; P$4 6.1,-5.7; VIN0 0,5.7; VIN1 6.1,5.7 | hole 2.032: 0,0; 4.572,0
USB-MINIB = smd 2.5 x 0.5: D+ 2.5,0; D- 2.5,0.8; GND 2.5,-1.6; ID 2.5,-0.8; VBUS 2.5,1.6 | smd 2.5 x 2: MTN1 -3,4.5; MTN2 2.5,4.5; MTN3 -3,-4.5; MTN4 2.5,-4.5 | hole 0.9: 0,2.2; 0,-2.2
2X3 = drill 1.016 pad 1.88 octagon: 1 0,0; 2 0,2.54; 3 2.54,0; 4 2.54,2.54; 5 5.08,0; 6 5.08,2.54
2X5_NOSILK = drill 1.016 pad 1.88 octagon: 1 -1.27,5.08; 2 1.27,5.08; 3 -1.27,2.54; 4 1.27,2.54; 5 -1.27,0; 6 1.27,0; 7 -1.27,-2.54; 8 1.27,-2.54; 9 -1.27,-5.08; 10 1.27,-5.08
2X3_SMT_POSTS = smd 1 x 3.17: 1 -2.54,-2.54; 2 -2.54,2.54; 3 0,-2.54; 4 0,2.54; 5 2.54,-2.54; 6 2.54,2.54 | hole 1.8: -1.27,0; 1.27,0
1X02 = drill 1.016 pad 1.88: 1 0,0; 2 2.54,0
XBEE-SMD = smd 1.7 x 0.85: 1 -12.5,20; 2 -9.5,18; 3 -12.5,16; 4 -9.5,14; 5 -12.5,12; 6 -9.5,10; 7 -12.5,8; 8 -9.5,6; 9 -12.5,4; 10 -9.5,2; 11 12.5,2; 12 9.5,4; 13 12.5,6; 14 9.5,8; 15 12.5,10; 16 9.5,12; 17 12.5,14; 18 9.5,16; 19 12.5,18; 20 9.5,20
MSOP8 = smd 0.4 x 1.1: 1 -0.975,-2.25; 2 -0.325,-2.25; 3 0.325,-2.25; 4 0.975,-2.25; 5 0.975,2.25; 6 0.325,2.25; 7 -0.325,2.25; 8 -0.975,2.25
0603-RES = smd 1.1 x 1: 1 -0.85,0; 2 0.85,0
AYZ0202 = smd 1 x 1.15: 1 -2.5,2.825; 2 0,2.825; 3 2.5,2.825; 4 -2.5,-2.825; 5 0,-2.825; 6 2.5,-2.825 | hole 0.85: 1.5,0; -1.5,0
TACTILE_SWITCH_SMD = smd 1.524 x 0.762: 1 -2.54,1.905; 2 2.54,1.905; 3 -2.54,-1.905; 4 2.54,-1.905
STAND-OFF = hole 3.302: 0,0
TQFP32-08 = smd 1.27 x 0.559: 1 -4.293,2.8; 2 -4.293,2; 3 -4.293,1.2; 4 -4.293,0.4; 5 -4.293,-0.4; 6 -4.293,-1.2; 7 -4.293,-2; 8 -4.293,-2.8; 17 4.293,-2.8; 18 4.293,-2; 19 4.293,-1.2; 20 4.293,-0.4; 21 4.293,0.4; 22 4.293,1.2; 23 4.293,2; 24 4.293,2.8 | smd 0.559 x 1.27: 9 -2.8,-4.293; 10 -2,-4.293; 11 -1.2,-4.293; 12 -0.4,-4.293; 13 0.4,-4.293; 14 1.2,-4.293; 15 2,-4.293; 16 2.8,-4.293; 25 2.8,4.293; 26 2,4.293; 27 1.2,4.293; 28 0.4,4.293; 29 -0.4,4.293; 30 -1.2,4.293; 31 -2,4.293; 32 -2.8,4.293
SSOP24 = smd 0.348 x 1.397: 1 -3.575,-3.656; 2 -2.925,-3.656; 3 -2.275,-3.656; 4 -1.625,-3.656; 5 -0.975,-3.656; 6 -0.325,-3.656; 7 0.325,-3.656; 8 0.975,-3.656; 9 1.625,-3.656; 10 2.275,-3.656; 11 2.925,-3.656; 12 3.575,-3.656; 13 3.575,3.656; 14 2.925,3.656; 15 2.275,3.656; 16 1.625,3.656; 17 0.975,3.656; 18 0.325,3.656; 19 -0.325,3.656; 20 -0.975,3.656; 21 -1.625,3.656; 22 -2.275,3.656; 23 -2.925,3.656; 24 -3.575,3.656
SOT23-5 = smd 0.55 x 1.2: 1 -0.95,-1.3; 2 0,-1.3; 3 0.95,-1.3; 4 0.95,1.3; 5 -0.95,1.3
SSOP28DB = smd 0.348 x 1.397: 1 -4.225,-3.656; 2 -3.575,-3.656; 3 -2.925,-3.656; 4 -2.275,-3.656; 5 -1.625,-3.656; 6 -0.975,-3.656; 7 -0.325,-3.656; 8 0.325,-3.656; 9 0.975,-3.656; 10 1.625,-3.656; 11 2.275,-3.656; 12 2.925,-3.656; 13 3.575,-3.656; 14 4.225,-3.656; 15 4.225,3.656; 16 3.575,3.656; 17 2.925,3.656; 18 2.275,3.656; 19 1.625,3.656; 20 0.975,3.656; 21 0.325,3.656; 22 -0.325,3.656; 23 -0.975,3.656; 24 -1.625,3.656; 25 -2.275,3.656; 26 -2.925,3.656; 27 -3.575,3.656; 28 -4.225,3.656
SOT353 = smd 0.42 x 0.7: 1 -0.65,-0.95; 2 0,-0.95; 3 0.65,-0.95; 4 0.65,0.95; 5 -0.65,0.95
RESONATOR-SMD = smd 0.7 x 1.7: 1 -1.2,0; 2 0,0; 3 1.2,0

### Placement (x,y rotation side)
C2  40.26,29.59 180 top
C3  53.72,27.18 0 top
C4  41.91,16.51 90 top
C5  68.58,21.59 0 top
C6  36.07,37.72 0 top
C7  53.98,18.92 0 top
C8  36.83,40.13 180 top
C9  10.41,4.06 0 top
D1  6.35,24.13 0 top
D2  86.36,6.35 180 top
D3  76.58,15.24 90 top
D4  62.23,24.13 180 top
D5  76.58,16.51 90 top
D6  56.9,45.72 90 top
FID1  6.35,48.26 0 top
FID2  87.63,1.27 0 top
FRAME1  not placed on the board
JP1  35.56,5.08 270 top
JP2  58.42,5.08 90 top
JP3  3.81,15.24 0 top
JP4  88.9,16.51 180 top
JP5  69.85,27.94 90 top
JP6  91.44,34.29 0 top
JP7  2.54,34.29 180 top
JP8  25.4,40.64 270 top
JP9  68.58,40.64 270 top
JP10  12.7,40.64 270 top
JP11  12.7,30.48 270 top
JP12  81.28,40.64 270 top
JP13  81.28,30.48 270 top
JP14  48.26,5.08 270 top
JP15  45.72,5.08 270 top
JP16  16.51,8.89 90 top
MOD1  46.99,15.24 0 top
Q1  16.51,22.86 90 top
R1  53.98,20.19 180 top
R2  41.91,46.99 0 top
R3  52.07,46.99 180 top
R4  51.82,43.81 90 top
R5  73.66,15.24 180 top
R6  73.66,16.51 180 top
R7  62.23,27.05 90 top
R8  59.69,45.72 0 top
R9  31.75,16.51 270 top
R10  30.48,9.91 0 top
R11  16.51,25.4 0 top
R12  55.75,16.64 90 top
R13  54.61,11.43 90 top
S1  25.4,12.7 180 top
S2  25.4,21.59 180 top
S3  46.99,44.45 270 top
S4  25.4,31.75 0 top
SFE-LOGO1  64.39,0.76 0 top
STANDOFF1  91.44,2.54 0 top
STANDOFF2  2.99,46.99 0 top
STANDOFF3  2.54,2.54 0 top
STANDOFF4  91.44,46.99 0 top
U1  46.99,29.21 0 top
U2  46.99,15.24 0 top
U3  15.24,5.08 90 top
U4  36.83,43.18 90 top
U5  67.31,15.24 270 top
U6  54.61,13.97 90 top
U$17  78.74,7.62 0 top
U$21  0,-2.54 0 top
Y1  40.13,26.67 270 top

### Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
3.3V
  Top 0.254: U4.5 35.53,41.5 35.43,41.4 C8.A 35.42,40.12 35.42,38.97 35.22,38.77 C6.1 35.22,36.62 34.49,35.89 MOD1.1
5V  (via drill 0.38, 0.51)
  Top 0.203: v40.01,30.86 40.39,30.48 41.02,30.48 41.16,30.34 41.16,29.64 C2.1 | U4.3 38.13,45.05 v38.1,45.09 37.08,45.09 36.83,44.83 36.83,42.55 37.15,42.23 U4.1 | v58.42,46.99 60.07,46.99 60.54,46.52 R8.2 | JP12.3 v76.2,40.64 | JP12.4 v86.36,40.64 | JP13.3 v76.2,30.48 | JP13.4 v86.36,30.48 | U2.20 46.02,17.69 45.72,17.4 44.07,17.4 v43.31,16.64 43.31,16 43.16,15.86 C4.1 | JP10.3 5.08,40.64 JP7.9 | v17.78,40.64 JP10.4 | JP11.3 v7.62,30.48 | JP11.4 v17.78,30.48 | C9.A 13.87,4.06 U3.5 14.92,4.13 v15.24,3.81 | v49.53,27.94 50.26,27.21 U1.18 52.16,27.21 52.2,27.18 C3.1 | v56.13,20.95 55.51,20.19 R1.1
  Top 0.254: C2.1 42.68,29.59 U1.4 44.19,29.61 | U1.6 43.74,28.01 v44.45,27.3 | v53.34,11.94 53.66,12.26 U6.5 53.67,13.34 54.48,13.34 54.61,13.21 R13.2 | R12.2 56.55,17.49 v57.02,17.02
  other vias: 15.24,5.08 15.24,6.35 44.96,29.72
  pour 5V (isolate 0.305): 2.54,49.53 91.44,49.53 arc-90 93.98,46.99 93.98,2.54 arc-90 91.44,0 2.54,0 arc-90 0,2.54 0,46.99 arc-90
FT232_RXI  (via drill 0.51)
  Top 0.254: U5.5 62.64,16.86 v61.98,16 | v54.61,46.99 R3.1
  Gnd 0.254: v61.98,16 61.72,46.23 60.96,46.99 59.69,45.72 57.15,45.72 55.88,46.99 v54.61,46.99
FT232_TXO  (via drill 0.51)
  Top 0.254: U5.1 64.93,19.46 v65.41,19.94 | v41.27,45.34 41.27,46.98 R2.1
  5V 0.254: v65.41,19.94 65.41,34.92 64.77,35.56 62.23,35.56 60.96,36.83 60.96,39.37 59.69,40.64 43.18,40.64 41.91,41.91 41.91,44.7 v41.27,45.34
FTDI_DTR
  Top 0.254: U5.2 62.38,18.82 61.85,18.29 61.85,17.53 57.64,13.32 U6.1 55.56,10.98 55.37,10.79 54.62,10.79 R13.1
GND  (via drill 0.38, 0.51)
  Top 0.254: 36.83,38.1 36.72,37.99 C6.2 v38.23,37.72 C8.C | U4.2 v39.5,43.18 | S1.3 21.62,9.88 v21.46,9.91 | C9.C v7.24,4.06 | U2.18 47.31,17.47 47.24,17.4 | C4.2 v40.51,17.14 | MOD1.10 37.49,16.28 v37.47,16 | Y1.2 v38.61,26.67 | U1.5 v44.09,28.81 v44.1,28.8 | U1.21 49.96,29.61 v49.9,29.6 | U5.21 69.53,14.91 v69.22,14.86 | U5.7 64.95,15.56 v65.15,15.49 | U5.25 69.48,17.52 v69.47,17.53 | U5.18 69.48,12.96 v69.47,12.95 | D4.C 63.49,23.38 v63.5,23.37 | C3.2 v54.48,28.45 | S4.1 v21.08,33.66 | U1.3 v44.09,30.41 v44.1,30.4 | D6.C v54.86,45.72 | S1.6 22.9,17.27 | 22.9,17.27 S2.3 | v21.59,17.14 22.77,17.14 22.9,17.27
  Top 0.305: JP4.GND 84.38,18.11 v84.33,18.16 | U3.2 v17.91,5.08 | Q1.1 18.76,19.98 v19.56,19.18
  Top 1.016: JP9.6 v73.66,38.1 | JP8.5 v20.32,38.1 | JP8.6 v30.48,38.1 | v7.24,9.53 7.25,9.54 JP3.P$4 12.56,9.54 v13.84,9.53 | JP10.6 v17.78,38.1 | JP10.5 v7.62,38.1 | JP11.6 v17.78,27.94 | JP11.5 v7.62,27.94 | JP12.6 v86.36,38.1 | JP13.6 v86.36,27.94 | JP13.5 v76.2,27.94 | JP12.5 v76.2,38.1 | JP9.5 v63.5,38.1
  Top 1.27: v7.24,9.53 3.83,9.53 JP3.GND
  other vias: 45.72,16.51 48.26,16.51 50.8,16.51 50.8,13.97 48.26,13.97 45.72,13.97 38.73,30.86
  pour Gnd (isolate 0.305): 2.54,49.53 91.44,49.53 arc-90 93.98,46.99 93.98,2.54 arc-90 91.44,0 2.54,0 arc-90 0,2.54 0,46.99 arc-90
  pour Bottom (isolate 0.305): 2.54,49.53 91.44,49.53 arc-90 93.98,46.99 93.98,2.54 arc-90 91.44,0 2.54,0 arc-90 0,2.54 0,46.99 arc-90
  pour Top (isolate 0.305): 44.58,10.92 49.4,10.92 49.4,12.57 49.53,12.7 51.18,12.7 51.18,17.78 47.24,17.78 46.48,17.02 44.58,17.02
  pour Top (isolate 0.305, rank 2): 2.54,49.53 91.44,49.53 arc-90 93.98,46.99 93.98,2.54 arc-90 91.44,0 2.54,0 arc-90 0,2.54 0,46.99 arc-90
L01
  Top 1.27: JP1.1 40.51,7.62 39.37,6.48 39.37,3.81 40.64,2.54 JP1.3 JP15.2
  pour Top (isolate 0.305): 43.18,12.32 44.2,12.32 44.2,7.11 41.4,7.11 41.4,8.26 41.27,8.26 43.18,10.16
L02
  pour Top (isolate 0.305): 45.85,12.32 46.74,12.32 46.74,5.59 45.72,4.57 41.4,4.57 41.4,5.71 44.58,5.71 45.85,6.99
L_CTRL_1  (via drill 0.38)
  Top 0.254: U2.21 45.37,20.47 v45.72,20.83 | v44.2,32 U1.32
  Bottom 0.254: v45.72,20.83 46.1,21.21 46.1,30.1 v44.2,32
L_CTRL_2  (via drill 0.38)
  Top 0.254: U1.2 41.31,31.21 v41.27,31.24 | U2.22 44.72,20.94 44.96,21.19 v44.96,21.72
  Bottom 0.254: v41.27,31.24 42.8,29.72 42.8,23.88 v44.96,21.72
MISO  (via drill 0.51)
  Top 0.254: U1.16 50.52,24.92 51.05,24.38 58.55,24.38 v59.18,23.75 | v63.75,25.4 69.22,25.4 v69.85,26.04 JP5.1
  5V 0.254: v59.18,23.75 62.1,23.75 v63.75,25.4
MOTOR_ENABLE  (via drill 0.38)
  Top 0.254: S2.2 v25.4,20.07 S1.5 | U2.19 46.66,20.26 v46.92,20.52
  5V 0.254: v46.92,20.52 46.92,16.44 46.1,15.62 38.48,15.62 37.97,15.11 36.96,15.11 36.45,15.62 28.19,15.62 25.4,18.41 v25.4,20.07
N$1
  Top 0.254: S3.2 51.8,44.45 R4.2
N$2
  Top 0.305: Q1.8 Q1.7 13.03,22.54 12.7,22.86 12.7,24.89 13.21,25.4 R11.1 15.86,26.27 16.13,26.54 18.03,26.54 18.76,25.82 Q1.4
N$3
  Top 0.254: R6.1 D5.C
N$4
  Top 0.254: R5.1 D3.C
N$5
  Top 0.254: U6.4 53.66,15.18 54.61,16.13 54.83,16.34 C7.2
N$6
  pour Top (isolate 0.305): 93.98,25.4 82.55,25.4 82.55,8.89 93.98,8.89
N$7
  Top 0.254: D4.A R7.1
N$8
  Top 0.254: D6.A R8.1
N$18
  Top 0.254: S2.1 31.4,18.77 31.75,18.41 R9.1
N$23
  Top 0.254: U1.8 41.78,26.41 40.84,25.47 Y1.3
N$24
  Top 0.254: U1.7 41.75,27.21 41.09,27.87 Y1.1
N$26
  Top 0.254: U5.16 78.97,11.66 83.02,15.71 JP4.D-
N$27  (via drill 0.51)
  Top 0.254: U5.15 81.25,11.02 v81.28,11.05 | JP4.D+ 81.53,16.51 v81.28,16.26
  5V 0.254: v81.28,11.05 v81.28,16.26
PG_EN
  Top 0.254: S1.1 29.8,9.88 R10.1
PROGRAM_ENABLE
  Top 0.254: U3.3 19.18,6.03 23.81,6.03 25.4,7.62 S1.2
  Top 0.305: Q1.2 17.71,22.54 17.27,22.1 17.27,19.3 19.05,17.53 19.05,6.16 19.18,6.03
PWML
  Top 0.203: U1.9 44.19,21.6 44.2,21.59 44.06,21.46 U2.23
PWMR  (via drill 0.25)
  Top 0.203: U1.10 44.99,23.15 v44.96,23.11 | v47.37,22.73 48.13,22.73 49.27,21.6 U2.15
  5V 0.203: v44.96,23.11 46.99,23.11
  5V 0.254: 46.99,23.11 v47.37,22.73
R01
  Top 1.27: JP14.2 JP2.1 53.34,2.54 54.61,3.81 54.61,6.35 53.34,7.62 JP2.3
  pour Top (isolate 0.305): 49.78,12.32 50.8,12.32 50.8,10.16 52.7,8.26 52.7,7.11 49.78,7.11
R02
  pour Top (isolate 0.305): 47.24,12.32 48.13,12.32 48.13,6.99 49.4,5.71 52.58,5.71 52.58,4.57 48.26,4.57 47.24,5.59
R_CTRL_1
  Top 0.203: U2.17 47.97,21.25 47.75,21.46 46.48,21.46 45.79,22.16 U1.11
R_CTRL_2
  Top 0.203: U1.12 46.59,22.24 46.86,21.97 48.01,21.97 48.62,21.36 U2.16
RESET  (via drill 0.51)
  Top 0.203: R1.2 53.12,21.63 v53.34,21.84 | C7.1 53.12,17.95 v52.32,17.14
  Top 0.254: v60.96,20.32 63.5,20.32 64.77,21.59 64.77,22.86 66.04,24.13 72.39,24.13 73.66,25.4 73.66,31.75 72.39,33.02 JP5.5 | U1.29 v46.59,32.02 | v25.4,29.84 S4.3 | R1.2 C7.1
  5V 0.254: v52.32,17.14 53.34,17.14 54.1,17.91 58.55,17.91 v60.96,20.32
  Gnd 0.254: v53.34,21.84 53.34,26.67 52.07,27.94 52.07,30.48 51.69,30.86 47.75,30.86 v46.59,32.02 46.59,33.17 46.1,33.66 42.16,33.66 40.51,32 38.73,32 36.96,30.23 25.78,30.23 v25.4,29.84
RXI
  Top 0.254: R2.2 42.6,46.95 S3.4 44.16,46.2 43.81,45.85 43.18,45.85 42.67,45.34 42.67,42.67 40.64,40.64 40.64,39.88 44.07,36.45 45.34,36.45 45.79,36 U1.30
RXLED
  Top 0.254: U5.22 71.94,15.56 72.26,15.24 R5.2
SCK
  Top 0.254: U1.17 51.28,25.68 51.56,25.4 57.15,25.4 59.56,27.81 60.58,27.81 61.98,29.21 62.23,29.21 | 62.23,29.21 68.58,29.21 JP5.3 | R7.2 62.23,29.21
SENSOR_0/SW_TXO  (via drill 0.51)
  Top 0.254: U1.23 52.8,31.21 53.34,31.75 v53.34,38.86 53.34,41.4 52.79,41.95 S3.3 | v7.49,43.18 JP10.1
  5V 0.254: v53.34,38.86 31.62,38.86 31.5,38.99 29.34,38.99 27.43,36.83 11.05,36.83 7.49,40.39 v7.49,43.18
SENSOR_1/SW_RXI  (via drill 0.51)
  Top 0.254: U1.24 51.28,40.16 50.8,40.64 44.07,40.64 | S3.6 44.16,40.74 44.07,40.64 | 44.07,40.64 v41.91,40.64 | v17.78,43.18 JP10.2
  Gnd 0.254: v41.91,40.64 34.29,40.64 30.48,44.45 19.05,44.45 v17.78,43.18
SENSOR_2  (via drill 0.38, 0.51)
  Top 0.254: U1.25 49.79,34.66 49.66,34.8 v49.02,34.8 | v7.62,33.02 JP11.1
  5V 0.254: v49.02,34.8 45.47,34.8 45.21,34.54 8.38,34.54 7.62,33.78 v7.62,33.02
SENSOR_3  (via drill 0.38, 0.51)
  Top 0.254: U1.26 48.99,32.29 v49.53,31.75 | v17.78,33.02 JP11.2
  5V 0.254: v49.53,31.75 48.26,31.75 46.99,30.48 45.97,30.48 45.34,31.11 45.34,32.64 44.96,33.02 41.78,33.02 41.66,32.89 41.27,32.89 40.39,32 39.24,32 38.23,33.02 22.48,33.02 21.97,32.51 18.29,32.51 v17.78,33.02
SENSOR_4  (via drill 0.51)
  Top 0.254: U1.27 48.19,35.24 48.64,35.69 v50.29,35.69 | v54.36,35.69 54.36,43.31 55.5,44.45 60.96,44.45 63.5,46.99 77.47,46.99 78.74,45.72 JP12.1
  Bottom 0.254: v50.29,35.69 v54.36,35.69
SENSOR_5  (via drill 0.51)
  Top 0.254: U1.28 47.39,36.47 48.01,37.08 v50.29,37.08 | v55.88,37.08 55.88,43.05 56.39,43.56 61.47,43.56 64.26,46.35 76.83,46.35 v77.47,45.72 | v80.01,45.72 83.44,45.72 83.82,45.34 JP12.2
  Bottom 0.254: v50.29,37.08 v55.88,37.08 | v77.47,45.72 v80.01,45.72
SENSOR_6
  Top 0.254: U1.19 52.27,28.01 52.83,28.57 52.83,29.21 53.34,29.72 57.4,29.72 58.42,30.73 64.77,30.73 65.15,31.11 65.15,33.66 66.29,34.8 72.64,34.8 74.42,33.02 JP13.1
SENSOR_7
  Top 0.254: U1.22 53.27,30.41 55.24,32.38 57.78,32.38 58.29,31.88 63.88,31.88 64.26,32.26 64.26,33.91 65.91,35.56 73.03,35.56 74.42,34.16 83.44,34.16 83.82,33.78 JP13.2
SERVO_1
  Top 0.254: U1.1 41.78,32.01 41.66,32.13 38.86,32.13 37.21,30.48 36.32,30.48 35.69,29.84 33.4,29.84 32.51,30.73 32.51,33.78 30.1,36.2 20.57,36.2 19.05,37.72 19.05,42.42 19.81,43.18 JP8.1
SERVO_2  (via drill 0.51)
  Top 0.254: U1.13 47.39,26.14 47.12,26.42 47.12,28.45 v47.88,29.21 | v43.18,35.56 36.83,35.56 35.18,33.91 33.53,33.91 33.02,34.42 33.02,41.4 31.24,43.18 JP8.2
  Bottom 0.254: v47.88,29.21 47.88,35.94 46.99,36.83 44.45,36.83 v43.18,35.56
SERVO_3  (via drill 0.51)
  Top 0.254: U1.14 48.19,26.6 v48.26,26.67 | v66.04,45.34 JP9.1
  Bottom 0.254: v48.26,26.67 60.2,26.67 61.09,27.56 61.09,42.8 61.47,43.18 63.88,43.18 v66.04,45.34
SERVO_4/MOSI  (via drill 0.51)
  Top 0.254: U1.15 48.99,24.04 49.4,23.62 50.67,23.62 v51.05,23.24 | JP9.2 71.12,44.7 v71.63,45.21
  Bottom 0.254: v51.05,23.24 57.28,23.24 59.05,25.02 62.36,25.02 62.87,25.53 62.87,28.57 64.77,30.48 | 64.77,30.48 JP5.4 | 64.77,30.48 64.77,34.29 66.04,35.56 71.12,35.56 72.39,36.83 72.39,44.45 v71.63,45.21
TXLED
  Top 0.254: U5.23 71.97,16.21 72.26,16.51 R6.2
TXO  (via drill 0.51)
  Top 0.254: U1.31 44.99,35.27 v44.83,35.43 | S3.1 51.38,46.95 R3.2 51.17,46.98 v51.18,45.72
  Gnd 0.254: v44.83,35.43 44.83,39.75 45.72,40.64 49.53,40.64 50.8,41.91 50.8,45.34 v51.18,45.72
V_BATT  (via drill 0.51)
  Top 0.254: U2.24 42.7,18.9 v42.16,18.92 | U2.14 U2.13 51.53,18.9 v51.69,18.92 | R11.2 17.36,23.96 16.76,23.37 v16,23.37
  Top 0.305: Q1.5 15.54,23.84 v16,23.37 15.82,23.18 Q1.6 | D1.A 4.2,23.25
  Top 1.016: 4.2,23.25 3.81,22.86 JP3.VIN0
  Top 1.27: D1.A v6.22,24.13
  Gnd 1.016: v6.22,24.13 6.22,20.45 7.62,19.05 16.51,19.05 | 16.51,19.05 21.59,24.13 29.34,24.13 34.54,18.92 v42.16,18.92 v51.69,18.92 | JP16.2 16.51,19.05
  Gnd 1.27: 16.51,19.05 16.51,22.86 v16,23.37
V_GATED  (via drill 0.51)
  Top 0.305: Q1.3 19.88,23.18 20.19,23.5
  Top 1.016: 20.19,23.5 v20.19,25.4 | JP8.3 v20.32,40.64 | v73.66,40.64 JP9.4 | JP9.3 v63.5,40.64 | JP8.4 v30.48,40.64
  5V 1.016: v20.32,40.64 20.32,46.74 21.46,47.88 30.48,47.88 | 30.48,47.88 45.34,47.88 45.97,48.51 63.5,48.51 | 63.5,48.51 73.41,48.51 74.3,47.62 74.3,40.64 v73.66,40.64 | v63.5,40.64 63.5,48.51 | v30.48,40.64 30.48,47.88
  Gnd 1.016: v20.19,25.4 20.19,31.75 19.68,32.26 19.68,36.07 19.05,36.7 19.05,39.37 v20.32,40.64
V_IN  (via drill 0.51)
  Top 0.254: U3.1 16.54,2.57 v16.51,2.54 | 31.13,2.65 v31.24,2.54 31.33,2.63 R10.2 31.33,13.17 31.75,13.59 R9.2
  Top 1.016: D2.C 84.21,2.93 v83.82,2.54 | D1.C v10.16,24.13
  5V 1.016: v83.82,2.54 57.15,2.54 52.07,7.62 41.91,7.62 36.83,2.54 v31.24,2.54 v16.51,2.54 12.7,2.54 11.43,3.81 11.43,22.86 v10.16,24.13
V_USB  (via drill 0.51)
  Top 0.203: D3.A 77.33,14.4 77.47,14.27
  Top 0.254: 76.96,14.27 U5.20 70.02,14.27 69.72,13.97 67.06,13.97 66.67,14.35 66.67,17.39 66.8,17.52 | 76.96,14.27 77.47,14.27 79.29,14.27 v79.88,14.86 | JP4.VBUS 84.76,14.91 v83.82,13.97 | U5.4 66.8,17.52 | 76.95,14.28 76.96,14.27 | D5.A D3.A | C5.1 67.73,17.82 67.44,17.53 66.81,17.53 66.8,17.52
  Top 0.813: v83.82,13.97 83.82,10.03 85.09,8.76 87.76,8.76 88.51,8.01 D2.A
  Gnd 0.254: v79.88,14.86 82.93,14.86 v83.82,13.97
XBEE_DIO3  (via drill 0.51)
  Top 0.254: 57.91,16.13 57.91,15.49 56.39,13.97 U6.2 | 57.91,16.13 57.91,20.7 v57.66,20.95 | v57.66,28.57 58.29,29.21 59.46,29.21 MOD1.17 | R12.1 57.77,15.99 57.91,16.13
  5V 0.254: v57.66,20.95 57.66,21.97 58.04,22.35 58.04,28.19 v57.66,28.57
XBEE_RXI  (via drill 0.38, 0.51)
  Top 0.254: MOD1.3 36.32,31.24 v36.83,31.75 | v53.34,44.45 53.34,43.43 52.87,42.97 R4.1
  Bottom 0.254: v53.34,44.45 53.34,40.64 52.2,39.37 43.56,39.37 41.78,37.59 41.78,33.66 39.88,31.75 v36.83,31.75
XBEE_TXO  (via drill 0.38, 0.51)
  Top 0.254: S3.5 44.16,43.4 v43.94,43.18 | MOD1.2 40.1,33.24 v40.13,33.27
  Bottom 0.254: v43.94,43.18 40.77,43.18 40.64,43.05 40.64,33.78 v40.13,33.27

### Text on the board
Bottom: v12
tPlace: XBEE HW SERIAL | SENSOR | SERVO | SERVO | SENSOR | A0 | A1 | 3 | 9 | POWER | 10 | 11 | A4 | A5 | 5V | 5V | POW | POW | POW | POW | 5V | 5V | GND | 5V | 5V | GND | XBEE SW SERIAL | GND | GND | GND | GND | GND | GND | GND | GND | SENSOR | SENSOR | A2 | A3 | A6 | A7 | 5V | 5V | 5V | 5V | GND | GND | RESET | GND | GND | MOTOR | USER LED | RUN | STOP | V_IN / 6-9V | POWER | TX | RX | ON | + | OFF | LEFT / MOTOR | RIGHT / MOTOR | - | RED | RED | BLACK | BLACK | RedBot
bPlace: sparkfun.com/redbot
tValues: M. Hord